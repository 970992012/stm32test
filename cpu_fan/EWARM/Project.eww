<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\cpu_fan.ewp</path>
  </project>
  <batchBuild />
</workspace>
